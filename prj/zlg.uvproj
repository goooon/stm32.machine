# Keil uVision project zlg.uvproj, settings and files
target zlg (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: zlg +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\sys;..\hwlib\STM32F10x_FWLib\inc;..\hwlib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h main.cpp
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group fwlib
    ../hwlib/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group sys
    ../sys/: delay.c sys.c usart.c
  group api
    ../api/: Event.cpp Event.h Keyboard.cpp Keyboard.h Lcd.cpp Lcd.h Queue.h Timer.h Tracer.cpp Tracer.h Encoder.h i2c.c i2c.h Encoder.c Tool.cpp Tool.h Timer.c FPGA.cpp Led.cpp
  group page
    ../page/: Page0.h Page1.h Page2.h Page3.h Page4.h Page5.h page.h Page6.h Page7.h Page8.h Page9.h Page10.h Page11.h Page12.h 新建文本文档.txt InputPage.h
  group setting
    ../setting/: setting.cpp setting.h
